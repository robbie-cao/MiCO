# IAR project demo.ewp, settings and files
configuration MiCOKit-LPC5410x (ARM)
  General.OGChipSelectEditMenu: LPC54102J512_M4 NXP LPC54102J512_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=16000000; CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\helloworld; ..\..\..\..\include; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-LPC5410x; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\LPC5410x\peripherals; ..\..\..\..\Platform\MCU\LPC5410x\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\Drivers\MiCOKit_EXT; ..\..\..\..\MICO; ..\..\..\..\libraries; ..\..\..\..\libraries\protocols; ..\..\..\..\libraries\utilities; ..\..\..\..\MICO\system; ..\..\..\..\MICO\system\command_console; ..\..\..\..\mico\security; ..\..\..\..\Platform\Drivers
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: demo.bin
  ILINK.IlinkOutputFile: demo.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-LPC5410x\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../../../../Demos/helloworld/: hello_world.c
  group Board/MiCOKit-LPC5410x
    ../../../../Board/MiCOKit-LPC5410x/: platform.c platform.h platform_config.h
  group include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group libraries/utilities
    ../../../../libraries/utilities/: AESUtils.c CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group libraries/utilities/json_c
    ../../../../libraries/utilities/json_c/: arraylist.c arraylist.h bits.h config.h debug.c debug.h json.h json_inttypes.h json_object.c json_object.h json_object_private.h json_tokener.c json_tokener.h json_util.c json_util.h linkhash.c linkhash.h printbuf.c printbuf.h
  group mico/core
    ../../../../mico/core/: mico_config.c mxchipWNet_cm4f_8801.a mxchipWNet_cm4f_sdio.a mxchipWNet_cm4f_spi.a
    ../../../../mico/core/RF driver/: wlan_firmware.c
  group mico/security
    ../../../../mico/security/Curve25519/: curve25519-donna.c
    ../../../../mico/security/SHAUtils/: hkdf.c hmac.c sha-private.h sha.h sha1.c sha224-256.c sha384-512.c usha.c
    ../../../../mico/security/: MicoCrypto.a MicoSrpServer.a
  group mico/system
    ../../../../mico/system/easylink/airkiss_discovery/: airkiss_discovery.c
    ../../../../mico/system/config_server/: config_server.c config_server_menu.c
    ../../../../mico/system/easylink/airkiss_discovery/lib_airkiss/: libairkiss.a
    ../../../../mico/system/easylink/: libMFiWAC.a system_easylink.c system_easylink_delegate.c system_easylink_wac.c
    ../../../../mico/system/command_console/: mico_cli.c mico_cli.h
    ../../../../mico/system/mdns/: mico_mdns.c mico_mdns.h system_discovery.c
    ../../../../mico/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c system.h system_factory_test.c system_misc.c
    ../../../../mico/system/tftp_ota/: tftp.h tftp_ota.c tftp_ota.h tftpc.o
  group Platform
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/display/VGM128064
    ../../../../Platform/Drivers/display/VGM128064/: AsciiLib.c AsciiLib.h oled.c oled.h oledfont.h
  group Platform/Drivers/keypad/gpio_button
    ../../../../Platform/Drivers/keypad/gpio_button/: button.c button.h
  group Platform/Drivers/led/P9813
    ../../../../Platform/Drivers/rgb_led/P9813/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group Platform/Drivers/MFiAuth
    ../../../../Platform/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/MiCOKit-EXT
    ../../../../Platform/Drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h micokit_ext_mfg.c motion_sensor.c motion_sensor.h temp_hum_sensor.c
  group Platform/Drivers/MiCOKit-STmem
    ../../../../Platform/Drivers/MiCOKit_STmems/: MiCOKit_STmems.c MiCOKit_STmems.h MiCOKit_STmems_def.h
  group Platform/Drivers/motor/dc_motor
    ../../../../Platform/Drivers/motor/dc_motor/: dc_motor.c dc_motor.h
  group Platform/Drivers/sensor/ADPS9930
    ../../../../Platform/Drivers/sensor/apds9930/: apds9930.c apds9930.h
  group Platform/Drivers/sensor/BMA2x2
    ../../../../Platform/Drivers/sensor/BMA2x2/: bma2x2.c bma2x2.h bma2x2_user.c bma2x2_user.h
  group Platform/Drivers/sensor/BME280
    ../../../../Platform/Drivers/sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
  group Platform/Drivers/sensor/BMG160
    ../../../../Platform/Drivers/sensor/BMG160/: bmg160.c bmg160.h bmg160_user.c bmg160_user.h
  group Platform/Drivers/sensor/BMM050
    ../../../../Platform/Drivers/sensor/BMM050/: bmm050.c bmm050.h bmm050_user.c bmm050_user.h
  group Platform/Drivers/sensor/DHT11
    ../../../../Platform/Drivers/sensor/DHT11/: DHT11.c DHT11.h
  group Platform/Drivers/sensor/HTS221
    ../../../../Platform/Drivers/sensor/HTS221/: hts221.c hts221.h
  group Platform/Drivers/sensor/infrared_adc
    ../../../../Platform/Drivers/sensor/infrared_adc/: infrared_reflective.c infrared_reflective.h
  group Platform/Drivers/sensor/light_adc
    ../../../../Platform/Drivers/sensor/light_adc/: light_sensor.c light_sensor.h
  group Platform/Drivers/sensor/LPS25HB
    ../../../../Platform/Drivers/sensor/LPS25HB/: lps25hb.c lps25hb.h
  group Platform/Drivers/sensor/LSM9DS1
    ../../../../Platform/Drivers/sensor/LSM9DS1/: lsm9ds1.h lsm9ds1_acc_gyr.c lsm9ds1_mag.c
  group Platform/Drivers/sensor/UVIS25
    ../../../../Platform/Drivers/sensor/UVIS25/: uvis25.c uvis25.h
  group Platform/Drivers/SPI Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/LPC5410x
    ../../../../Platform/MCU/LPC5410x/: platform_init.c
  group Platform/LPC5410x/EWARM
    ../../../../Platform/MCU/LPC5410x/EWARM/: startup_lpc54100_EWARM.s
  group Platform/LPC5410x/Peripherals
    ../../../../Platform/MCU/LPC5410x/peripherals/: platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_peripheral.h platform_mcu_powersave.c platform_nano_second.c platform_pwm.c platform_rng.c platform_rtc.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/LPC5410x/Peripherals/Libraries
    ../../../../Platform/MCU/LPC5410x/peripherals/Libraries/: adc_5410x.c chip_5410x.c clock_5410x.c crc_5410x.c dma_5410x.c fifo_5410x.c fpu_init.c gpio_5410x.c gpiogroup_5410x.c i2c_common_5410x.c i2cm_5410x.c i2cs_5410x.c iap.c iocon_5410x.c pinint_5410x.c pll_5410x.c power_control.c ring_buffer.c ritimer_5410x.c rtc_5410x.c rtc_ut.c sct_5410x.c sct_pwm_5410x.c spi_5410x.c spi_common_5410x.c spim_5410x.c spis_5410x.c stopwatch_5410x.c syscon_5410x.c sysinit_5410x.c timer_5410x.c uart_5410x.c utick_5410x.c wwdt_5410x.c
  group Platform/LPC5410x/Wi-Fi_Bus_Driver
    ../../../../Platform/MCU/LPC5410x/wlan_bus_driver/: wlan_bus_spi.c wlan_platform.c
